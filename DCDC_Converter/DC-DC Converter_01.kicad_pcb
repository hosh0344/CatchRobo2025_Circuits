# Repository hosh0344/CatchRobo2025_Circuits

File README.md:

# キャチロボ2025で使用した回路 <br>

MCUにはArduino Uno R4に搭載のRenesasの[R7FA4M1AB3CFM](https://akizukidenshi.com/catalog/g/g118159/)を使用し、Arduino IDEで開発を行いました。 <br>

## 1. SVMD2025

4chのシンプルなサーボモータ制御回路です。

ファイルは[こちら](https://github.com/hosh0344/CatchRobo2025_Circuits/tree/main/DRC-SVMD2025) <br><br>

## 2. SLVD2025

4chの電磁弁駆動回路。電源電圧は5Vでも対応可能。

NMOSは[2SK4017](https://akizukidenshi.com/catalog/g/g107597/)

ファイルは[こちら](https://github.com/hosh0344/CatchRobo2025_Circuits/tree/main/DRC-SLVD2025) <br> <br>

## 3. DCDCコンバータ

Murataの[OKL-T/6-W12N-C](https://akizukidenshi.com/catalog/g/g106187/)を用いた5Vの降圧チョッパ回路。

出力電圧は可変抵抗で4.5V-5.5Vまで調整可能です。

ファイルは[こちら](https://github.com/hosh0344/CatchRobo2025_Circuits/tree/main/DCDC_Converter)

## KiCad design DCDC_Converter/DC-DC Converter_01.kicad_pcb

Board: 2 copper layers, 60.0 x 45.0 mm, 10 parts (0 on the bottom side), 6 nets.

Parts:
C1: 22u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C2: 10u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
J1: ON/OFF; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
J2: Vin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3: Vout; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
R1: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 500; Potentiometer_Vishay_T73YP_Vertical
U1: OKL-T-6-W12N-C_0; MURATA_OKL-T-6-W12N-C_0

Connections:
+5V: C2.1, J3.2, R3.1, U1.4 (Vout), U1.5 (Sence)
+12V: C1.1, J2.2, R1.1, U1.2 (Vin)
GNDPWR: C1.2, C2.2, J1.1, J2.1, J3.1, R3.2, RV1.2, RV1.3, U1.3 (GND), U1.7 (GND)
unnamed: J1.2, R1.2, U1.1 (ON/OFF)
unnamed: R2.2, RV1.1
unnamed: R2.1, U1.6 (Trim)

## KiCad design DRC-SLVD2025/DRC-SLVD2025.kicad_pcb

Parts:
C1, C5, C7: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C6, C8, C9: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 220u; CP_Radial_D8.0mm_P3.50mm
C15: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: SS2040FL; D_SOD-123F
D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D3, D4, D5, D6: D_Schottky_Small; D_SOD-123F
D7: +5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J7, J8: CAN; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J9: BATTERY; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J11: SLV0; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J12: SLV2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J13: SLV1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J14: SLV3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
JP1: BOOT; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: CAN_TR; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1, Q2, Q3, Q4: 2SK4017; TO230P230X650X740-3P
R1, R2, R3, R4, R7, R8, R11: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R14, R15, R19, R20: 2.4k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13, R17, R18, R21, R22: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RESET; SW_SPST_EVQPE1
SW2: ID; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
U1: R7FA4M1AB3CFM_AA0; R7FA4M1AB3CFM; PARTREV 1.1
U2: MCP2562-H-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3: TLP293-4; SOIC-16_4.55x10.3mm_P1.27mm

Connections:
+3.3V: C5.2, C6.1, U1.4 (VBATT), U1.20 (VCC_USB)
+5V: C1.2, C2.2, C3.1, C4.1, C8.2, C9.2, D1.1 (K), D2.1 (VDD), J7.4, J8.4, R1.1, R4.1, R7.2, R8.2, R9.1, R11.1, R21.1, U1.11 (VCC), U1.21 (VCC_USB_LDO), U1.39 (VCC), U1.56 (AVCC0), U2.3 (VDD), U2.5 (Vio)
+12V: C10.1, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J9.2, J11.2, J12.2, J13.2, J14.2, U3.10, U3.12, U3.14, U3.16
/A0: SW2.1, U1.53 (DA0/AN009/P014)
/A1: SW2.2, U1.64 (AN000/P000)
/A2: SW2.3, U1.63 (P001)
/A3: SW2.4, U1.62 (P002)
/A4: U1.47 (GTIOC5A/AN021/P101)
/A5: U1.48 (GTIOC5B/AN022/P100)
/BOOT: JP1.2 (B), R8.1, U1.26 (MD/P201)
/D0/RX: U1.31 (GTIOC4B/P301)
/D1/TX: U1.30 (GTIOC4A/P302)
/D2: U1.43 (GTIOC1A/P105)
/D7: U1.41 (GTIOC0A/P107)
/D11/MOSI: U1.34 (CTX0/TDO/SWO/GTIOC1A/P109)
/D12/MISO: U1.35 (CRX0/RDI/GTIOC1B/P110)
CAN_H: J7.3, J8.3, JP2.2 (B), U2.7 (CANH)
CAN_L: J7.2, J8.2, R16.2, U2.6 (CANL)
CAN_RX: U1.46 (ADTRG0/GTIOC2B/AN020/P102), U2.4 (RXD)
CAN_TX: U1.45 (GTIOC2A/AN019/P103), U2.1 (TXD)
GND: C1.1, C2.1, C3.2, C4.2, C5.1, C6.2, C7.2, C8.1, C9.1, C15.2, D2.3 (VSS), D7.1 (K), D8.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J7.1, J8.1, JP1.1 (A), R3.2, R5.2, R6.2, R10.2, R12.2, R13.2, R17.1, R18.2, SW1.1, SW2.5, SW2.6, SW2.7, SW2.8, U1.8 (VSS), U1.17 (VSS_USB), U1.40 (VSS), U1.57 (AVSS0), U2.2 (VSS), U2.8 (STBY)
GNDPWR: C10.2, J9.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), R14.2, R15.2, R19.2, R20.2
LED: R22.1, U1.36 (GTIOC3A/P111)
unnamed: D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: D3.2 (A), J11.1, Q1.2 (D)
unnamed: D4.2 (A), J13.1, Q2.2 (D)
unnamed: D5.2 (A), J12.1, Q3.2 (D)
unnamed: D6.2 (A), J14.1, Q4.2 (D)
unnamed: D7.2 (A), R21.2
unnamed: D8.2 (A), R22.2
unnamed: J1.A5 (CC1), R5.1
unnamed: J1.B5 (CC2), R6.1
unnamed: JP2.1 (A), R16.1
unnamed: Q1.1 (G), R14.1, U3.15
unnamed: Q2.1 (G), R15.1, U3.13
unnamed: Q3.1 (G), R19.1, U3.11
unnamed: Q4.1 (G), R20.1, U3.9
unnamed: R2.2, R3.1
unnamed: R12.1, U3.2
unnamed: R13.1, U3.4
unnamed: R17.2, U3.6
unnamed: R18.1, U3.8
unnamed: R9.2, R10.1, U1.49 (GTIOC2A/AN016/P500)
unnamed: R7.1, U1.27 (NMI/INPUT/GTIOC1A/P200)
unnamed: C15.1, R11.2, U1.59 (P010/AN005/VREFH0)
unnamed: R1.2, R2.1, U1.16 (P407/USB_VBUS/ADTRG0)
unnamed: C7.1, U1.5 (VCL)
RESET: R4.2, SW1.2, U1.25 (~RES)
RGB: D2.4 (DIN), U1.28 (GTIOC7A/P304)
SOLV0: U1.44 (GTIOC1B/P104), U3.1
SOLV1: U1.42 (GTIOC0B/P106), U3.3
SOLV2: U1.37 (GTIOC3B/P112), U3.5
SOLV3: U1.29 (GTIOC7B/P303), U3.7
USB_D_N: J1.A7 (D-), J1.B7 (D-), U1.18 (P915/USB_DM)
USB_D_P: J1.A6 (D+), J1.B6 (D+), U1.19 (P914/USB_DP)

Notes on the sheet:
PWM出力可能ピン:3,5,6,9,10,11

Board: 2 copper layers, 60.0 x 45.0 mm, 60 parts (38 on the bottom side), 47 nets.

## Code that names these connections

File DRC-SVMD2025/SVMD2025_ver2.1.ino:

#include <Arduino_CAN.h>
#include <Servo.h>

//通信関係
#define CAN_RX 5
#define CAN_TX 4
//LED関係
#define LED 13
#define RGB 8
//DIPスイッチ
#define SW0 A0
#define SW1 A1
#define SW2 A2
#define SW3 A3
//Servo出力
#define SV0 3
#define SV1 6
#define SV2 10
#define SV3 9

//CANID
int ID ;

Servo servo0;
Servo servo1;
Servo servo2;
Servo servo3;

//DIPスイッチを読み取る
void readSwitch() {
  int readNumber = !digitalRead(SW0) + 2 * !digitalRead(SW1) + 4 * !digitalRead(SW2) + 8 * !digitalRead(SW3);

  ID = 0x10 + readNumber;
  Serial.print("ID:");
  Serial.println(ID);
}

//ここに処理を記入(case0は例なので注意)
void readData(uint32_t command, int32_t value) {
  switch (command) {
    case 0:
    servo0.write(constrain(value, 0, 180));
      break;
  }
}

void setup() {

  pinMode(SW0, INPUT_PULLUP);
  pinMode(SW1, INPUT_PULLUP);
  pinMode(SW2, INPUT_PULLUP);
  pinMode(SW3, INPUT_PULLUP);
  pinMode(LED, OUTPUT);
  pinMode(RGB, OUTPUT);

  Serial.begin(115200);  //シリアル初期化

  if (!CAN.begin(CanBitRate::BR_500k)) {
    Serial.println("CAN.begin(...) failed.");
  }
  readSwitch();  //DIPスイッチの読み出し

  servo0.attach(SV0);
  servo1.attach(SV1);
  servo2.attach(SV2);
  servo3.attach(SV3);
}

void loop() {
  //CAN受信かつid一致(0x12)で受信データ読み出し＆目標の再設定
  if (CAN.available()) {
    CanMsg const msg = CAN.read();
    int id = msg.id;  //IDを取得
    int length = msg.data_length;

    for (int i = 0; i < 8; i++) {
      Serial.print(msg.data[i], HEX);
    }
    Serial.println();

    if (id == ID && length == 8) {
      uint32_t command = 0;
      int32_t value = 0;

      for (int i = 0; i < 4; i++) {
        command |= (msg.data[i] << (8 * (3 - i)));
        value |= (msg.data[4 + i] << (8 * (3 - i)));
      }
      //command,value毎の処理
      readData(command, value);
    }
  }
}
